Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: 0001
Time: 2023-12-04T15:58:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Dec 04 15:58:07 2023 * Host: RENSON-PC64rjMe * Database: C:\Users\naniw\AppData\Local\Temp\7ffb2f03-d42b-4b59-844a-c944a62f6276\ad1a3bf2-f5a1-49e9-b73a-2315cda1537d\ifc * Database version: 5507 * Database creation date: Mon Dec 04 15:58:07 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Dec 04 15:58:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Dec 04 15:58:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: 8mm Head

# IfcController: Brain Module, Renson_Control Unit_Brain:Brain Module:370416
In: Level 1
Type - Classification: 86000007 (Uniformat); Material: Color RAL 7035, Color RGB 138-110-075, Color RGB 043-043-044, Color RAL 7016
Type - Pset_ControllerTypeCommon - Reference: Brain Module
Type - Pset_EnvironmentalImpactIndicators - Reference: Brain Module
Type - Pset_ManufacturerTypeInformation - Manufacturer: Renson
Type - Pset_ElectricalDeviceCommon - RatedVoltage: 258.334 A
Pset_ControllerTypeCommon - sets with these values: 2
